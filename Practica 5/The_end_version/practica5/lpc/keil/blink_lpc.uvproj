# Keil uVision project blink_lpc.uvproj, settings and files
target LPC_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Inicio
    ../src_lpc/: Startup.s
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h drv_botones.c drv_botones.h drv_consumo.c drv_consumo.h drv_monitor.c drv_monitor.h hal_consumo.h hal_ext_int.h hal_WDT.h rt_evento_t.h rt_fifo.c rt_fifo.h rt_GE.c rt_GE.h svc_alarma.c svc_alarma.h hal_SC.h hal_Random.h simon.c simon.h test.c test.h
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c hal_tiempo_lpc.c reserva_gpio_lpc2105.h hal_consumo_lpc.c hal_ext_int_lpc.c hal_WDT_lpc.c hal_SC_lpc.c hal_random_lpc.c
target LPC_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: as above
  output: blink_lpc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
